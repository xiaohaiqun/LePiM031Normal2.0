# Keil uVision project LePaiM031.uvprojx, settings and files
target LePai (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M031TB0AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.5
  cpu: IRAM(0x20000000,0x800) IROM(0x00000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: LePai +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\..\Library\CMSIS\Include;..\..\Library\Device\Nuvoton\M031\Include;..\..\Library\StdDriver\inc;..\DeviceDrive\include;..\M031Relative\Include;..\RaspberryI2C1\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  link misc: --map --first='startup_M031Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../Library/Device/Nuvoton/M031/Source/: system_M031Series.c
    ../../Library/Device/Nuvoton/M031/Source/ARM/: startup_M031Series.s
  group Library
    ../../Library/StdDriver/src/: retarget.c uart.c clk.c gpio.c sys.c i2c.c timer.c pwm.c
  group Device
    ../DeviceDrive/source/: BMM150.c ButtonProcess.c IP5328.c LSM6DSL.c pwm_light.c
  group RaspberryI2C1
    ../RaspberryI2C1/Source/: I2C1Dev.c
  group M031
    ../M031Relative/Source/: I2C0Dev.c SYS_init.c TimerPeriodic.c
  group User
    ../: main.c
